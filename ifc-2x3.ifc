Properties of the parts of a building model (IFC2X3)

# File
Description: Ersatz-Fahne für Windfahnenrelais JSL-1E, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6150031, Ersatz-Fahne für Windfahnenrelais JSL-1E
In: Raum
Description: Ersatz-Fahne für Windfahnenrelais JSL-1E, Material V2 A (1.4301). Bei höheren Luftgeschwindigkeiten als 5 m/s ist aufgrund der Bruchgefahr die Fahne an den angegebenen Markierungen seitlich zu beschneiden.; Classification: EC011319 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6150031; ModelLabel: JZ-08; GlobalTradeItemNumber: 4050528031433; ProductURL: https://alre.de/produkt_E6150031
Pset_Specification - NominalLength: 0.175 m; NominalWidth: 0.0795 m; NominalDepth: 0.001 m; NetWeight: 0.017
Pset_ALRE_ETIM_Properties - Ersatzteil: yes; ETIM-Klasse: EC011319; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6150031.pdf
